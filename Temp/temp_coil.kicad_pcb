File: Temp/temp_coil.kicad_pcb (KiCad board)
At the start: 2 copper layers, 0 parts

Commit message: 2nd layer Loop antenna Exporting
Routing:
- net (no net): track 1105.2 -> 1165.2 mm
